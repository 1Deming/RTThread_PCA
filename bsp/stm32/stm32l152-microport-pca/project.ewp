# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VE ST STM32L152VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\drivers\sensors; ..\..\..\components\drivers\include; ..\libraries\STM32L1xx_HAL\STM32L1xx_HAL_Driver\Inc; .; applications; ..\libraries\HAL_Drivers\config; board; ..\libraries\STM32L1xx_HAL\CMSIS\Device\ST\stm32l1xx\Include; ..\..\..\components\libc\compilers\common; ..\libraries\STM32L1xx_HAL\CMSIS\Include; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l1xx_hal_msp.c
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xe.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group CORTEX-M4
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    ../../../components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_usb.c stm32l1xx_ll_utils.c
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
